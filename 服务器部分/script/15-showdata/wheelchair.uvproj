# Keil uVision project wheelchair.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: wheelchair +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\app
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./app/: send.c mpu6050.c heart.c oled.c
